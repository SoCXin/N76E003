# Keil uVision project demo.uvproj, settings and files
target modbus (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\user\Modbus
  group user
    ./user/: main.c STARTUP.A51
    ./user/Modbus/: SimpleModbus.c
  group Common
    ./Common/: Common.c Delay.c
